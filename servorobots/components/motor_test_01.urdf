Commit message: Working simple motor

File: servorobots/components/motor_test_01.urdf (robot description, URDF)
Before this commit: robot motor_test_01, 3 links, 2 joints
Links:
- link childA: mass 1.0 -> 0
